# Keil uVision project smartwatch.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: smartwatch
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F411xE
  c include: .\CMSIS;.\USER\inc;.\SYSTEM;.\SYSTEM\inc;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ./CMSIS/: system_stm32f4xx.c startup_stm32f411xe.s
  group SYSTEM
    ./SYSTEM/src/: delay.c sys.c usart.c spi.c
  group FreeRTOS_CORE
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group USER
    ./USER/src/: main.c led.c motor.c exit.c key.c rtc.c oled.c sht20.c hp6.c hp6_IIC.c
